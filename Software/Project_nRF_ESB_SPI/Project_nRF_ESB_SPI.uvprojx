# Keil uVision project Project_nRF_ESB_SPI.uvprojx, settings and files
target nrf51422_xxac (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51_esb +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF_LOG_USES_RTT=1 NRF51
  c include: .\Sources;..\Common\nRF_SDK\device;..\Common\nRF_SDK\drivers_nrf\common;..\Common\nRF_SDK\drivers_nrf\config;..\Common\nRF_SDK\drivers_nrf\delay;..\Common\nRF_SDK\drivers_nrf\hal;..\Common\nRF_SDK\drivers_nrf\nrf_soc_nosd;..\Common\nRF_SDK\drivers_nrf\spi_master;..\Common\nRF_SDK\drivers_nrf\spi_slave;..\Common\nRF_SDK\libraries\util;..\Common\nRF_SDK\properitary_rf\esb;..\Common\nRF_SDK\toolchain;..\Common\nRF_SDK\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./Sources/: esb_spi_bridge.c
  group nRF_Drivers
    ../Common/nRF_SDK/drivers_nrf/delay/: nrf_delay.c
    ../Common/nRF_SDK/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../Common/nRF_SDK/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../Common/nRF_SDK/drivers_nrf/common/: nrf_drv_common.c
  group nRF_Libraries
    ../Common/nRF_SDK/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
  group nRF_Properitary_RF
    ../Common/nRF_SDK/properitary_rf/esb/: nrf_esb.c
  group Device
    ./Sources/Device/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 4.3.0
