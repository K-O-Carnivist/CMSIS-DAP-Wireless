# Keil uVision project Project_STM32_HID.uvprojx, settings and files
target STM32F072 Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project_STM32_HID +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072x8
  c misc: --C99
  c include: .\Includes;.\Sources\Device;..\Common;..\Common\STM32F0xx_HAL_Driver\Inc;..\Common\STM32F0xx_HAL_Driver\Inc\Legacy;..\Common\STM32_USB_Device_Library\Core\Inc;..\Common\STM32_USB_Device_Library\Class\CustomHID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Sources
    ./Sources/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usbd_custom_hid_if.c usb_device.c usbd_conf.c usbd_desc.c
    ../Common/: DAP_Common.h
  group STM32_USB_Device_Library
    ../Common/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Common/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group STM32F0xx_HAL_Driver
    ../Common/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Device
    ./Sources/Device/: startup_stm32f072xb.s system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
